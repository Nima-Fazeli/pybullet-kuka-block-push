Commit message: corrected the in plane motion

File: block_big.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- link block_2_base_link: geometry collision box size=0.10 0.05 0.05; visual box size=0.15 0.15 0.05
